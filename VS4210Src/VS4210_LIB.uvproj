# Keil uVision project VS4210_LIB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: .\VS4210_lib +hex (library)
  c flags: Optimize=9
  c include: ..\EPG026_Firmware_VS4210\Segments\Segments1\VS4210;..\EPG026_Firmware_VS4210\EPG026HCI;..\EPG026_Firmware_VS4210\Segments
  group Source Group 1
    ./: VS4210.c
